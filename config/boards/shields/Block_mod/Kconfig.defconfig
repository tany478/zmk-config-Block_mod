## config/boards/shields/Block_mod/Kconfig.defconfig
```kconfig
if SHIELD_BLOCK_MOD

config ZMK_KEYBOARD_NAME
    default "Block_mod"

    
endif
```
